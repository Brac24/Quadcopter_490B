# Keil uVision project compdcm_mpu9150.uvproj, settings and files
target compdcm_mpu9150 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: compdcm_mpu9150
  AfterMake: fromelf --bin --output .\rvmdk\compdcm_mpu9150.bin .\rvmdk\compdcm_mpu9150.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_TM4C123_RB1 UART_BUFFERED
  c misc: --c99
  c include: ..;..\..\..\..;C:\ti\TivaWare_C_Series-2.1.3.156
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: compdcm_mpu9150.sct
  link misc: --entry Reset_Handler
  group Source
    ./: compdcm_mpu9150.c startup_rvmdk.S tPID.c tMotor.c
    C:/ti/TivaWare_C_Series-2.1.3.156/examples/boards/ek-tm4c123gxl-boostxl-senshub/drivers/: rgb.c
    C:/ti/TivaWare_C_Series-2.1.3.156/utils/: uartstdio.c
  group Libraries
    C:/ti/TivaWare_C_Series-2.1.3.156/driverlib/rvmdk/: driverlib.lib
    C:/ti/TivaWare_C_Series-2.1.3.156/sensorlib/rvmdk/: sensorlib.lib
  group Documentation
    ./: readme.txt
